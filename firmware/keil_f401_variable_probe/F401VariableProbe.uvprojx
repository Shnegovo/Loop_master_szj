# Keil uVision project F401VariableProbe.uvprojx, settings and files
target STM32F401CCU6 Variable Probe (ARM-ADS)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(16000000) ELITTLE
  output: f401_variable_probe +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT1: ROM 0x00000000 size 0x00000000
  memory RVCT2: RAM 0x00000000 size 0x00000000
  memory RVCT3: RAM 0x00000000 size 0x00000000
  memory RVCT4: ROM 0x08000000 size 0x00040000
  memory RVCT5: RAM 0x00000000 size 0x00000000
  memory RVCT6: RAM 0x00000000 size 0x00000000
  memory RVCT7: RAM 0x00000000 size 0x00000000
  memory RVCT8: RAM 0x00000000 size 0x00000000
  memory RVCT9: RAM 0x20000000 size 0x00010000
  memory RVCT10: RAM 0x00000000 size 0x00000000
  group Application
    ./: main.c
  group Startup
    ./: startup_stm32f401ccux.s
  group Linker
    ./: f401_variable_probe.sct
